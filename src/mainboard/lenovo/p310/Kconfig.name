## src/mainboard/lenovo/p310/Kconfig.name
```kconfig
## SPDX-License-Identifier: GPL-2.0-only

config BOARD_LENOVO_P310
	bool "ThinkStation P310"
```
